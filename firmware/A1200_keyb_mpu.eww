<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\A1200_keyb_mpu.ewp</path>
  </project>
  <batchBuild/>
</workspace>


